# Keil uVision project CAN_Test.uvprojx, settings and files
target CAN_Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CAN_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\CORE\arm;..\FWLib\inc;..\USER;..\SYSTEM\delay;..\HARDWARE\USART;..\HARDWARE\CAN
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c
    ../CORE/arm/: startup_stm32f10x_hd.s
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/CAN/: can_test.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
