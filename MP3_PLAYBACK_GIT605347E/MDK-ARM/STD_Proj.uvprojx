# Keil uVision project STD_Proj.uvprojx, settings and files
target STD_Proj (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD_Proj +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\CORE\arm;..\FWLib\inc;..\USER;..\HARDWARE\GPIO;..\SYSTEM\delay;..\HARDWARE\EXTI;..\HARDWARE\USART;..\AUDIO;..\AUDIO\pff;..\AUDIO\helix\pub;..\AUDIO\helix\real
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c
    ../CORE/arm/: startup_stm32f10x_hd.s
    ../HARDWARE/EXTI/: exti.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/USART/: usart.c
  group AUDIO
    ../AUDIO/: audio_player.c audio_record.c board_audio.c sdcard_stub.c
    ../AUDIO/pff/: diskio.c pff.c
    ../AUDIO/helix/: mp3dec.c mp3tabs.c
    ../AUDIO/helix/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
