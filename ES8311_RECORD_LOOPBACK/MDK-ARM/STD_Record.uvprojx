# Keil uVision project STD_Record.uvprojx, settings and files
target STD_Record (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD_Record +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\CORE\arm;..\FWLib\inc;..\USER;..\AUDIO_RECORD;..\HARDWARE\GPIO;..\SYSTEM\delay;..\HARDWARE\EXTI;..\HARDWARE\USART;..\AUDIO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c
    ../CORE/arm/: startup_stm32f10x_hd.s
    ../HARDWARE/EXTI/: exti.c
  group USER
    ../AUDIO_RECORD/: record_main.c
    ../USER/: stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/USART/: usart.c
  group AUDIO_RECORD
    ../AUDIO_RECORD/: record_audio_record.c record_board_audio.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
